<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>D:\development\GitHub\Etching-Pcb-Embedded-Program\Program\EtchingPCB.ewp</path>
    </project>
    <batchBuild />
</workspace>

# IAR project EtchingPCB.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\development\GitHub\Etching-Pcb-Embedded-Program\Program\lib; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\stm8\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: EtchingPCB.hex
  ILINK.IlinkOutputFile: EtchingPCB.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
    lib/: veres_debug_via_UART_stm8.h veres_ds18b20_stm8.h veres_err_list_stm8.h veres_sound_stm8.h veres_timer2_stm8.h
